# Keil uVision project app_RTOS.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: app_RTOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG BLE_STACK_SUPPORT_REQD BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD FREERTOS NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_SD_BLE_API_VERSION=6 S132 SOFTDEVICE_PRESENT __HEAP_SIZE=1024 __STACK_SIZE=2048
  c misc: --reduce_paths
  c include: ..\App_src;..\App_BLE_services;..\App_Devices;..\App_Peripherals_API;..\App_Peripherals_Drivers;..\Debug_Monitor;..\FreeRTOS\source\include;..\FreeRTOS\portable\ARM\nrf52;..\FreeRTOS\portable\CMSIS\nrf52;..\nrf_BLE;..\nrf_BLE_Softdevice;..\nrf_Libraries;..\nrf_Libraries\integration\nrfx;..\nrf_Libraries\integration\nrfx\legacy;..\nrf_Log;..\SEGGER_RTT;..\SEGGER_sysview;..\libraries\util;..\softdevice\s132\headers;..\modules\nrfx\drivers\include;..\modules\nrfx\drivers\include;..\modules\nrfx\soc;..\modules\nrfx\hal;..\libraries\experimental_log\src;..\libraries\delay;..\modules\nrfx;..\libraries\mutex;..\libraries\fds;..\libraries\atomic
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress 6330
  group App_src
    ../App_src/: app_pin_configuration.c app_queues.c app_startup.c app_tasks_list.c main.c
  group App_Devices
    ../App_Devices/: ads1292r.c BQ25120.c BQ27421.c
  group App_Peripherals_API
    ../App_Peripherals_API/: led.c spi.c twim.c
  group App_Peripherals_Drivers
    ../App_Peripherals_Drivers/: app_drv_gpio.c app_drv_gpiote.c app_drv_spi.c app_drv_twi.c app_drv_uarte.c app_hal_gpio.c app_hal_gpiote.c app_hal_spi.c app_hal_twi.c app_hal_uarte.c
  group App_BLE_services
    ../App_BLE_services/: app_acc_service.c app_dts_service.c app_helper.c
  group Debug_Monitor
    ../Debug_Monitor/: JLINK_MONITOR.c
  group FreeRTOS
    ../FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/source/portable/MemMang/: heap_1.c
    ../FreeRTOS/portable/CMSIS/nrf52/: port_cmsis.c port_cmsis_systick.c
    ../FreeRTOS/portable/ARM/nrf52/: port.c
  group nrf_BLE
    ../nrf_BLE/: ble_advdata.c ble_advertising.c ble_conn_params.c ble_conn_state.c ble_db_discovery.c ble_link_ctx_manager.c ble_srv_common.c gatt_cache_manager.c gatts_cache_manager.c id_manager.c nrf_ble_gatt.c nrf_ble_qwr.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
    ../nrf_Libraries/: app_util_platform.c
  group nrf_BLE_Softdevice
    ../nrf_BLE_Softdevice/: nrf_sdh.c nrf_sdh_ant.c nrf_sdh_ble.c nrf_sdh_freertos.c nrf_sdh_soc.c
  group nrf_Libraries
    ../nrf_Libraries/: app_error.c app_error_handler_keil.c app_error_weak.c app_timer_freertos.c fds.c hardfault_handler_keil.c hardfault_implementation.c nrf_assert.c nrf_atfifo.c nrf_atflags.c nrf_atomic.c nrf_balloc.c nrf_fprintf.c nrf_fprintf_format.c nrf_fstorage.c nrf_fstorage_sd.c nrf_memobj.c nrf_pwr_mgmt.c nrf_section_iter.c nrf_strerror.c
  group nrf_Log
    ../nrf_Log/src/: nrf_log_backend_flash.c nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group SEGGER_RTT
    ../SEGGER_RTT/: SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_KEIL.c
  group SEGGER_sysview
    ../SEGGER_sysview/: SEGGER_RTT.c SEGGER_SYSVIEW.c SEGGER_SYSVIEW_Config_FreeRTOS.c SEGGER_SYSVIEW_FreeRTOS.c
software components: CMSIS:CORE 5.1.2, Device:Startup 8.17.0, Device:StartupConfig 8.17.0
